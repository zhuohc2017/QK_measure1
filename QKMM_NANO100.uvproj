# Keil uVision project QKMM_NANO100.uvproj, settings and files
target QKMM (ARM-ADS)
  device: NANO100SD3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(42000000) CPUTYPE("Cortex-M0")
  output: QKMM_NANO100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\inc;.\inc\cmsis_inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ./CMSIS/: startup_Nano100Series.s system_Nano100Series.c
  group Driver
    ./src/: platform.c user_usart.c w25q64.c user_spi.c user_adc.c
  group User
    ./user/: main.c
    ./src/: app.c
  group Lib
    ./src/: adc.c clk.c crc.c dac.c ebi.c fmc.c gpio.c i2c.c i2s.c lcd.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
